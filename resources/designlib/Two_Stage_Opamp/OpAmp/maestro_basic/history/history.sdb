<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Apr 25 07:56:21 2018</timestamp>
			<uuid>{8598dfd7-3bc7-4f41-a007-27f71eb4bca0}</uuid>
			<locked>1</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/hartong/projects/RAK/EAV_RAK/libs/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/hartong/projects/RAK/EAV_RAK/libs/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/hartong/projects/RAK/EAV_RAK/simulation/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Sep 3 08:26:03 2018</timestamp>
			<uuid>{a63abd10-5b6f-46d7-a7f0-2fb8640569bf}</uuid>
			<locked>1</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/vols/VFE_PE_T3_vol01/arja/EAV_RAK_618/EAV_RAK/libs/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/vols/VFE_PE_T3_vol01/arja/EAV_RAK_618/EAV_RAK/libs/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/vols/VFE_PE_T3_vol01/arja/EAV_RAK_618/EAV_RAK/simulation/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Two_Stage_Opamp/OpAmp/maestro_basic/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
