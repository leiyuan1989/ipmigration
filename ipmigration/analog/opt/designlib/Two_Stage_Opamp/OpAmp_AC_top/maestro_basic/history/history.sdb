<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Sep 4 06:40:27 2018</timestamp>
			<uuid>{aad7f69b-6a40-4b56-9374-24732c98c95e}</uuid>
			<locked>0</locked>
			<mode>Monte Carlo Sampling</mode>
			<resultsname>/vols/VFE_PE_T3_vol01/arja/EAV_RAK_618/EAV_RAK/libs/Two_Stage_Opamp/OpAmp_AC_top/maestro_basic/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/vols/VFE_PE_T3_vol01/arja/EAV_RAK_618/EAV_RAK/libs/Two_Stage_Opamp/OpAmp_AC_top/maestro_basic/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/vols/VFE_PE_T3_vol01/arja/EAV_RAK_618/EAV_RAK/simulation/Two_Stage_Opamp/OpAmp_AC_top/maestro_basic/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Two_Stage_Opamp/OpAmp_AC_top/maestro_basic/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
